# Keil uVision project mobang.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mobang +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\USART;..\SYSTEM\sys;..\SYSTEM\systick;..\HARDWARE\IWDG;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\DHT11;..\HARDWARE\RTC;..\HARDWARE\TIM3;..\HARDWARE\IIC;..\HARDWARE\ESP8266;..\HARDWARE\LCD;..\HARDWARE\PEOPLE;..\HARDWARE\TOUCH;..\HARDWARE\IMAGE2LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --libpath=H:\Download\Keil_v5\Keil_v5\ARM\ARMCC\lib
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_fsmc.c
  group HARDWARE
    ../HARDWARE/Delay/: Delay.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/IIC/: 24cxx.c myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIM3/: tim3.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ESP8266/: esp8266_uart4.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/PEOPLE/: people.c
    ../HARDWARE/TOUCH/: xpt2046.c touch.c
    ../HARDWARE/IMAGE2LCD/: image1.c image2lcd.c
  group HEADFILE
    ../SYSTEM/sys/: sys.h
    ../SYSTEM/systick/: systick.h
    ../HARDWARE/PWM/: pwm.h
    ../HARDWARE/USART/: usart.h
    ../HARDWARE/IIC/: 24cxx.h myiic.h
    ../HARDWARE/KEY/: key.h
    ../HARDWARE/LED/: led.h
    ../HARDWARE/BEEP/: beep.h
    ../HARDWARE/EXTI/: exti.h
    ../HARDWARE/TIM3/: tim3.h
    ../HARDWARE/IWDG/: iwdg.h
    ../HARDWARE/RTC/: rtc.h
    ../HARDWARE/DHT11/: dht11.h
    ../HARDWARE/ADC/: adc.h
    ../HARDWARE/ESP8266/: esp8266_uart4.h
    ../HARDWARE/LCD/: lcd.h cfont.h
    ../HARDWARE/PEOPLE/: people.h
    ../HARDWARE/TOUCH/: touch.h xpt2046.h
    ../HARDWARE/IMAGE2LCD/: image2lcd.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/systick/: systick.c
  group PIC
    ../HARDWARE/IMAGE2LCD/: smart_on.c smart_off.c
